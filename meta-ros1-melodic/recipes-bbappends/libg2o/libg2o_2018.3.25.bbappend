ROS_BUILD_DEPENDS += " \
    libglu \
"