ROS_UNRESOLVED_DEP-python-cairosvg = ""
ROS_UNRESOLVED_DEP-python-joblib = ""  
DEPENDS += "std-srvs"                  

